LINUX_VERSION ?= "5.2.21"
LINUX_RPI_BRANCH ?= "rpi-5.2.y"

SRCREV = "c3692f63d16ab3c4fca572e82e47b10c796c4d91"

require linux-raspberrypi_5.2.inc
